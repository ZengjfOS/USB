# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB 8051 AnchorChips
  cpu: IRAM(0 - 0xFF) CLOCK(25000000) MODDP2
  output: slave +hex
  AfterMake: C:\Cypress\USB\CY3684_EZ-USB_FX2LP_DVK\1.0\Bin\Hex2bix.exe -i -f 0xC2 slave.iic slave.hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: FW.C DSCR.A51 slave.c USBJmpTb.OBJ EZUSB.LIB eeprom.c eeprom.h
